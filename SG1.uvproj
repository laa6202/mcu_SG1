# Keil uVision project SG1.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SG1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\src\hmi;.\src;.\FWLIB\inc;.\src\rng
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ./CORE/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
  group lib
    ./FWLIB/src/: stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rng.c misc.c
  group src
    ./src/: main.c timer.c
    ./src/hmi/: led.c gpio.c
    ./src/rng/: rng.c
